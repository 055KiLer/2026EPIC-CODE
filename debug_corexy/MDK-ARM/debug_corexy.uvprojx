# Keil uVision project debug_corexy.uvprojx, settings and files
target debug_corexy (6220000::V6.22::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: debug_corexy +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Config;../User/Algorithm/Inc;../User/App/Inc;../User/Bsp/Inc;../User/Devices/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c usart.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../Core/Inc/: main.h stm32f4xx_hal_conf.h stm32f4xx_it.h tim.h usart.h
  group Application/User/App
    ../User/App/Src/: dbg_app.c dbg_console.c
    ../User/App/Inc/: dbg_app.h dbg_console.h
  group Application/User/Devices
    ../User/Devices/Src/: zdt_bus.c servo_out.c k230_uart.c dbg_vision.c tjc_screen.c
    ../User/Devices/Inc/: servo_out.h k230_uart.h dbg_vision.h tjc_screen.h zdt_bus.h
  group Application/User/Bsp
    ../User/Bsp/Src/: dbg_print.c dbg_uart.c dbg_gpio.c
    ../User/Bsp/Inc/: dbg_print.h dbg_uart.h dbg_gpio.h
  group Application/User/Algorithm
    ../User/Algorithm/Src/: motion_kinematics.c
    ../User/Algorithm/Inc/: motion_kinematics.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
